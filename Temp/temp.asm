ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL SORT
HERE: SJMP HERE
ORG 130H
SORT:
MOV R0,#70H
MOV R1,#60H
STORE:
MOV A,@R1
MOV @R0,A
INC R0
INC R1
CJNE R0,#78H,STORE
MOV R1,#00H
OUTLOOP:
MOV R0,#70H
INC R1
CJNE R1,#08H,INLOOP
RET
INLOOP:
MOV A,@R0
INC R0
CLR C
SUBB A,@R0
JNC SWAPPING
GOINGBACK:
MOV A,#78H
CLR C
SUBB A,R1
MOV 69H,R0
CJNE A,69H,INLOOP
LJMP OUTLOOP
SWAPPING:
MOV 06H,@R0
DEC R0
MOV 07H,@R0
MOV @R0,06H
INC R0
MOV @R0,07H
CLR C
JNC OUTLOOP
END